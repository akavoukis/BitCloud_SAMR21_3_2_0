# IAR project ATSAMR21G18A_ZAppSINP.ewp, settings and files
configuration All_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_8MHz; STACK_TYPE_ALL; NO_SECURITY_MODE
  ICCARM.CCDiagSuppress: Pa050,Pe188
  ICCARM.PreInclude: MakerulesBc_All_Atsamr21g18a_Rf233_Iar.h
  ICCARM.CCIncludePath2: ..; ../include; ../../../BitCloud/Components/BSP/SAMR21/include; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/std/include; ../../../BitCloud/Components/PersistDataServer/wl/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/VCP/include; ../../../BitCloud/Components/HAL/cortexm0+/atsamr21/common/include; ../../../BitCloud/Components/ZAppSI/include; ../../../BitCloud/Components/ZAppSI/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/MAC_HWD/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ATSAMR21G18A
  OBJCOPY.OOCOutputFile: ZAppSINP.srec
  ILINK.IlinkOutputFile: ZAppSINP.out
  ILINK.IlinkIcfFile: ../linkerScr/atSAMR21G18A_FLASH.icf
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_8MHz; STACK_TYPE_ALL; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_8MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_4MHz; STACK_TYPE_ALL; NO_SECURITY_MODE
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_4MHz; STACK_TYPE_ALL; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_4MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_16MHz; STACK_TYPE_ALL; NO_SECURITY_MODE
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_16MHz; STACK_TYPE_ALL; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_16MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_24MHz; STACK_TYPE_ALL; NO_SECURITY_MODE
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_24MHz; STACK_TYPE_ALL; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_24MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_48MHz; STACK_TYPE_ALL; NO_SECURITY_MODE
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_48MHz; STACK_TYPE_ALL; STANDARD_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; AT86RF233; HAL_48MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.PreInclude: MakerulesBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
  group src
    ../src/: ZAppSINP.c
  group include
    ../include/: ZAppSINP.h
  group Components/PersistDataServer/std/src
    ../../../BitCloud/Components/PersistDataServer/std/src/: stdPdsMemAccess.c stdPdsTimer.c stdPdsMem.c stdPdsWriteData.c stdPdsCrcService.c stdPdsInit.c stdPdsEvents.c stdPdsDataServer.c
  group Components/PersistDataServer/std/include
    ../../../BitCloud/Components/PersistDataServer/std/include/: stdPdsDbg.h stdPdsFiles.h stdPdsWriteData.h stdPdsTimer.h stdPdsMemAccess.h stdPdsMemAbstract.h stdPdsCrcService.h stdPdsMem.h stdPdsMemIds.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: fakePds.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h pdsMemIds.h
  group Components/PersistDataServer/wl/src
    ../../../BitCloud/Components/PersistDataServer/wl/src/: wlPdsTypesConverter.c wlPdsTaskManager.c wlPdsSecurity.c wlPdsInit.c wlPdsDataServer.c
  group Components/PersistDataServer/wl/nv_components/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/src/: S_Nv.c S_Nv-External.c S_Nv_Stub.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src/: S_XNv.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src/: D_XNv-SamR21.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/src/: D_Nv.c
  group Components/PersistDataServer/wl/nv_components/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include/: S_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include/: D_XNv_Init.h D_XNv_Bindings.h D_XNv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include/: D_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include/: S_XNv_Bindings.h
  group Components/PersistDataServer/wl/include
    ../../../BitCloud/Components/PersistDataServer/wl/include/: wlPdsBindings.h wlPdsSecurity.h wlPdsMemIds.h wlPdsTypesConverter.h wlPdsTaskManager.h wlPdsTypes.h
  group Components/SystemEnvironment/src
    ../../../BitCloud/Components/SystemEnvironment/src/: sysIdleHandler.c sysSleep.c sysStat.c sysEventsHandler.c sysQueue.c sysUtils.c sysAssert.c sysDuplicateTable.c sysInit.c sysTaskManager.c dbg.c sysMutex.c sysTimer.c
  group Components/SystemEnvironment/include
    ../../../BitCloud/Components/SystemEnvironment/include/: sysEventsHandler.h dbg.h sysTaskManager.h sysQueue.h sysDuplicateTable.h sysIdleHandler.h sysSleep.h sysEvents.h sysUtils.h sysMutex.h sysTimer.h sysStat.h sysIncrementMacro.h sysDbg.h sysAssert.h sysRepeatMacro.h sysTypes.h sysInit.h sysEndian.h
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/SAMR21/src/: bspUsart.c MaxL.c bspTempSensor.c buttons.c fakeBSP.c lcd.c xyl2rgb.c joyStick.c bspUid.c bspI2c.c bspVoltageSensor.c bspTaskManager.c hs2xy.c leds.c bspSpi.c
  group Components/BSP/include
    ../../../BitCloud/Components/BSP/SAMR21/include/: bspTaskManager.h bspDbg.h bspLeds.h ledsExt.h bspVoltageSensor.h bspTempSensor.h
    ../../../BitCloud/Components/BSP/SAMR21/src/: bspI2c.h
  group Components/ZAppSI/src
    ../../../BitCloud/Components/ZAppSI/src/: zsiZdoSerialization.c zsiKeSerialization.c zsiMac.c zsiNotify.c zsiDriver.c zsiHalSerialization.c zsiNwk.c zsiZdpSerialization.c zsiApsSerialization.c zsiNwkSerialization.c zsiTaskManager.c zsiHal.c zsiMacSerialization.c zsiBspSerialization.c zsiSys.c zsiMem.c zsiBsp.c zsiSpiAdapter.c zsiKe.c zsiAps.c zsiSysSerialization.c zsiZdo.c zsiUsartAdapter.c zsiSerialController.c zsiMemoryManager.c zsiSerializer.c zsiInit.c zsiStubs.c zsiZdp.c zsiSynchronization.c
  group Components/ZAppSI/include
    ../../../BitCloud/Components/ZAppSI/include/: zsiZdoSerialization.h zsiMemoryManager.h zsiFrames.h zsiApsSerialization.h zsiDbg.h zsiInit.h zsiHalSerialization.h zsiSerialController.h zsiTaskManager.h zsiMacSerialization.h zsiMem.h zsiSerialInterface.h zsiCommandId.h zsiSerializer.h zsiZdpSerialization.h zsiNwkSerialization.h zsiBspSerialization.h zsiNotify.h zsiKeSerialization.h zsiSysSerialization.h zsiDriver.h
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: csDefaults.h configServer.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csConstTable.h csBuffers.h csMemTable.h csVarTable.h csSIB.h csDbg.h
  group configuration
    ../: configuration.h
