<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild/>
  <project>
    <path>$WS_DIR$\ATSAMR21E18A_ZAppSINP.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ATSAMR21G18A_ZAppSINP.ewp</path>
  </project>
</workspace>
