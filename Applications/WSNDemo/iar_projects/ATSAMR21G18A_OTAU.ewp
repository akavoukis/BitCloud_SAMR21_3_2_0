# IAR project ATSAMR21G18A_OTAU.ewp, settings and files
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_8MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.CCDiagSuppress: Pa050,Pe188
  ICCARM.PreInclude: MakerulesBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ICCARM.CCIncludePath2: ..; ../include; ../../../BitCloud/Components/BSP/SAMR21/include; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/std/include; ../../../BitCloud/Components/PersistDataServer/wl/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/VCP/include; ../../../BitCloud/Components/HAL/cortexm0+/atsamr21/common/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/OFD/include; ../../../BitCloud/Components/HAL/drivers/ISD/include; ../../../BitCloud/Components/ZCL/include/private; ../../../BitCloud/Components/ZCL/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/MAC_HWD/include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: ATSAMR21G18A
  OBJCOPY.OOCOutputFile: WSNDemo.srec
  ILINK.IlinkOutputFile: WSNDemo.out
  ILINK.IlinkIcfFile: ../linkerScr/atSAMR21G18A_FLASH_OTAU.icf
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Coordinator_StdlinkSec_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_8MHz; STDLINK_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCARM.PreInclude: MakerulesBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
configuration Router_StdlinkSec_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_8MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCARM.PreInclude: MakerulesBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
configuration EndDevice_StdlinkSec_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_8MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCARM.PreInclude: MakerulesBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_8MHz; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_8MHz; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_4MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ALL
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration Coordinator_StdlinkSec_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_4MHz; STDLINK_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCARM.PreInclude: MakerulesBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration Router_StdlinkSec_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_4MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCARM.PreInclude: MakerulesBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration EndDevice_StdlinkSec_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_4MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCARM.PreInclude: MakerulesBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_4MHz; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_4MHz; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_16MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ALL
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration Coordinator_StdlinkSec_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_16MHz; STDLINK_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCARM.PreInclude: MakerulesBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration Router_StdlinkSec_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_16MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCARM.PreInclude: MakerulesBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration EndDevice_StdlinkSec_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_16MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCARM.PreInclude: MakerulesBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_16MHz; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_16MHz; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_24MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ALL
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration Coordinator_StdlinkSec_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_24MHz; STDLINK_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCARM.PreInclude: MakerulesBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration Router_StdlinkSec_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_24MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCARM.PreInclude: MakerulesBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration EndDevice_StdlinkSec_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_24MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCARM.PreInclude: MakerulesBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_24MHz; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_24MHz; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_48MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ALL
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
configuration Coordinator_StdlinkSec_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_48MHz; STDLINK_SECURITY_MODE; STACK_TYPE_COORDINATOR
  ICCARM.PreInclude: MakerulesBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Coordinator_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
configuration Router_StdlinkSec_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_48MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ROUTER
  ICCARM.PreInclude: MakerulesBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_Router_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
configuration EndDevice_StdlinkSec_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_48MHz; STDLINK_SECURITY_MODE; STACK_TYPE_ENDDEVICE
  ICCARM.PreInclude: MakerulesBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_EndDevice_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
configuration All_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_48MHz; NO_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
configuration All_Sec_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; BOOT_OTAU; HAL_48MHz; STANDARD_SECURITY_MODE; STACK_TYPE_ALL
  ICCARM.PreInclude: MakerulesBc_All_Sec_Atsamr21g18a_Rf233_Iar.h
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_Sec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
  group src
    ../src/: WSNCommandHandler.c WSNSensorManager.c WSNEndDevice.c WSNZclManager.c WSNCoord.c WSNMessageSender.c WSNVisualizer.c WSNRouter.c WSNDemoApp.c WSNUARTManager.c
  group include
    ../include/: WSNZclManager.h WSNVisualizer.h WSNUARTManager.h WSNMessageSender.h WSNCoord.h WSNDemoApp.h WSNEndDevice.h WSNRouter.h WSNCommandHandler.h WSNSensorManager.h WSNCommand.h serialInterface.h
  group Components/PersistDataServer/std/src
    ../../../BitCloud/Components/PersistDataServer/std/src/: stdPdsMemAccess.c stdPdsTimer.c stdPdsMem.c stdPdsWriteData.c stdPdsCrcService.c stdPdsInit.c stdPdsEvents.c stdPdsDataServer.c
  group Components/PersistDataServer/std/include
    ../../../BitCloud/Components/PersistDataServer/std/include/: stdPdsDbg.h stdPdsFiles.h stdPdsWriteData.h stdPdsTimer.h stdPdsMemAccess.h stdPdsMemAbstract.h stdPdsCrcService.h stdPdsMem.h stdPdsMemIds.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: fakePds.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h pdsMemIds.h
  group Components/PersistDataServer/wl/src
    ../../../BitCloud/Components/PersistDataServer/wl/src/: wlPdsTypesConverter.c wlPdsTaskManager.c wlPdsSecurity.c wlPdsInit.c wlPdsDataServer.c
  group Components/PersistDataServer/wl/nv_components/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/src/: S_Nv.c S_Nv-External.c S_Nv_Stub.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src/: S_XNv.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src/: D_XNv-SamR21.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/src/: D_Nv.c
  group Components/PersistDataServer/wl/nv_components/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include/: S_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include/: D_XNv_Init.h D_XNv_Bindings.h D_XNv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include/: D_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include/: S_XNv_Bindings.h
  group Components/PersistDataServer/wl/include
    ../../../BitCloud/Components/PersistDataServer/wl/include/: wlPdsBindings.h wlPdsSecurity.h wlPdsMemIds.h wlPdsTypesConverter.h wlPdsTaskManager.h wlPdsTypes.h
  group Components/SystemEnvironment/src
    ../../../BitCloud/Components/SystemEnvironment/src/: sysIdleHandler.c sysSleep.c sysStat.c sysEventsHandler.c sysQueue.c sysUtils.c sysAssert.c sysDuplicateTable.c sysInit.c sysTaskManager.c dbg.c sysMutex.c sysTimer.c
  group Components/SystemEnvironment/include
    ../../../BitCloud/Components/SystemEnvironment/include/: sysEventsHandler.h dbg.h sysTaskManager.h sysQueue.h sysDuplicateTable.h sysIdleHandler.h sysSleep.h sysEvents.h sysUtils.h sysMutex.h sysTimer.h sysStat.h sysIncrementMacro.h sysDbg.h sysAssert.h sysRepeatMacro.h sysTypes.h sysInit.h sysEndian.h
  group Components/OFD/src
    ../../../BitCloud/Components/HAL/drivers/OFD/src/: ofdCommand.c ofdM25Driver.c ofdAt45dbDriver.c ofdSpiSerializer.c ofdFakeDriver.c ofdCrcService.c ofdAt25Driver.c
  group Components/ZCL/src
    ../../../BitCloud/Components/ZCL/src/: zclKeyEstablishmentCluster.c zclOtauClientPdt.c zclSecurityManager.c zclParser.c zclOtauClientDownload.c zclOtauManager.c zclOtauClientQuery.c zclOtauClientDiscovery.c zclCommandAnalyzer.c zclOtauClientUpgrade.c zclOtauClient.c zclTaskManager.c zclAttributes.c zcl.c zclMemoryManager.c zclOtauServer.c
  group Components/ZCL/include
    ../../../BitCloud/Components/ZCL/include/: zclThermostatUiConfCluster.h zclTaskManager.h zclThermostatCluster.h zclPriceCluster.h zclOccupancySensingCluster.h zclInt.h zclIlluminanceMeasurementCluster.h zclHumidityMeasurementCluster.h zclFanControlCluster.h zclAttributes.h zclIdentifyCluster.h zclMessagingCluster.h zclKeyEstablishmentCluster.h zcl.h zclSecurityManager.h zclSmartEnergyTunnelCluster.h zclScenesCluster.h zclOtauManager.h zclBasicCluster.h zclAlarmsCluster.h zclBACnetProtocolTunnelCluster.h zclOnOffSwitchConfigurationCluster.h clusters.h eccAux.h zclOnOffCluster.h genericEcc.h zclIasZoneCluster.h zclLevelControlCluster.h zclIasACECluster.h zclOTAUCluster.h zclOtauClient.h zclDiagnosticsCluster.h zclTemperatureMeasurementCluster.h zclCommandAnalyzer.h zclTimeCluster.h zclGroupsCluster.h zclSimpleMeteringCluster.h zclDemandResponseCluster.h zclPowerConfigurationCluster.h zclGenerictunnelCluster.h zclParser.h zclMemoryManager.h zclMem.h
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/SAMR21/src/: bspUsart.c MaxL.c bspTempSensor.c buttons.c fakeBSP.c lcd.c xyl2rgb.c joyStick.c bspUid.c bspI2c.c bspVoltageSensor.c bspTaskManager.c hs2xy.c leds.c bspSpi.c
  group Components/BSP/include
    ../../../BitCloud/Components/BSP/SAMR21/include/: bspTaskManager.h bspDbg.h bspLeds.h ledsExt.h bspVoltageSensor.h bspTempSensor.h
    ../../../BitCloud/Components/BSP/SAMR21/src/: bspI2c.h
  group Components/ISD/src
    ../../../BitCloud/Components/HAL/drivers/ISD/src/: isdImageStorage.c isdConsoleTunneling.c
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: csPersistentMem.c csMem.c configServer.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: csDefaults.h configServer.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csConstTable.h csBuffers.h csMemTable.h csVarTable.h csSIB.h csDbg.h
  group configuration
    ../: configuration.h
