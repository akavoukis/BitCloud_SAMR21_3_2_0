<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>All_StdlinkSec_SamR21_Atsamr21e18a_Rf233_8Mhz</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>All_StdlinkSec_SamR21_Atsamr21e18a_Rf233_4Mhz</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>All_StdlinkSec_SamR21_Atsamr21e18a_Rf233_16Mhz</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>All_StdlinkSec_SamR21_Atsamr21e18a_Rf233_24Mhz</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>All_StdlinkSec_SamR21_Atsamr21e18a_Rf233_48MHz</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CombinedInterface</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciAlarmsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciBasicCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciClusters.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciDiagnosticsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciFanControlCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciGroupsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciHumidityMeasurementCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciIasACECluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciIasZoneCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciIdentifyCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciIlluminanceMeasurementCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciLevelControlCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciOccupancySensingCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciOnOffCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciPowerConfigurationCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciScenesCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciTemperatureMeasurementCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciThermostatCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciThermostatUiConfCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\include\ciTimeCluster.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciAlarmsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciBasicCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciClusters.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciConsole.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciDiagnosticsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciFanControlCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciGroupsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciHumidityMeasurementCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciIasACECluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciIasZoneCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciIdentifyCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciIlluminanceMeasurementCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciLevelControlCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciOccupancySensingCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciOnOffCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciPowerConfigurationCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciScenesCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciTemperatureMeasurementCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciThermostatCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciThermostatUiConfCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\ciTimeCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\combinedInterface\src\combinedInterface.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>common</name>
    <group>
      <name>clusters</name>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\common\clusters\include\basicCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\clusters\include\haClusters.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\common\clusters\include\identifyCluster.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\common\clusters\src\haClusters.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\common\include\appConsts.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\include\commandManager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\include\console.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\include\ezModeManager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\include\otauService.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\include\uartManager.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\include\zclDevice.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\common\src\commandManager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\src\console.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\src\ezModeManager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\src\keyboardPoll.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\src\otauService.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\src\uartManager.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\common\src\zclDevice.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Components</name>
    <group>
      <name>BSP</name>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\include\bspDbg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\bspI2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\include\bspLeds.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\include\bspTaskManager.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\include\bspTempSensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\include\bspVoltageSensor.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\include\ledsExt.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\bspI2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\bspSpi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\bspTaskManager.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\bspTempSensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\bspUid.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\bspUsart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\bspVoltageSensor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\buttons.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\fakeBSP.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\hs2xy.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\joystick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\lcd.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\leds.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\maxL.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\BSP\SAMR21\src\xyl2rgb.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>ConfigServer</name>
      <group>
        <name>include</name>
        <group>
          <name>private</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\include\private\csBuffers.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\include\private\csConstTable.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\include\private\csDbg.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\include\private\csMemTable.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\include\private\csSIB.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\include\private\csVarTable.h</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\include\configServer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\include\csDefaults.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\src\configServer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\src\csMem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ConfigServer\src\csPersistentMem.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>PersistDataServer</name>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\include\pdsDataServer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\include\pdsMemIds.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\src\fakePds.c</name>
        </file>
      </group>
      <group>
        <name>std</name>
        <group>
          <name>include</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsCrcService.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsDbg.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsFiles.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsMem.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsMemAbstract.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsMemAccess.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsMemIds.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsTimer.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\include\stdPdsWriteData.h</name>
          </file>
        </group>
        <group>
          <name>src</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\src\stdPdsCrcService.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\src\stdPdsDataServer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\src\stdPdsEvents.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\src\stdPdsInit.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\src\stdPdsMem.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\src\stdPdsMemAccess.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\src\stdPdsTimer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\std\src\stdPdsWriteData.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>wl</name>
        <group>
          <name>include</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\include\wlPdsBindings.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\include\wlPdsMemIds.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\include\wlPdsSecurity.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\include\wlPdsTaskManager.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\include\wlPdsTypes.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\include\wlPdsTypesConverter.h</name>
          </file>
        </group>
        <group>
          <name>nv_components</name>
          <group>
            <name>include</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\D_Nv\include\D_Nv.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\D_XNv\include\D_XNv.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\D_XNv\include\D_XNv_Bindings.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\D_XNv\include\D_XNv_Init.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\S_Nv\include\S_Nv.h</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\S_XNv\include\S_XNv_Bindings.h</name>
            </file>
          </group>
          <group>
            <name>src</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\D_Nv\src\D_Nv.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\D_XNv\src\D_XNv-SamR21.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\S_Nv\src\S_Nv-External.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\S_Nv\src\S_Nv.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\S_Nv\src\S_Nv_Stub.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZLLPlatform\ZLL\S_XNv\src\S_XNv.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>src</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\src\wlPdsDataServer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\src\wlPdsInit.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\src\wlPdsSecurity.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\src\wlPdsTaskManager.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\BitCloud\Components\PersistDataServer\wl\src\wlPdsTypesConverter.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>SystemEnvironment</name>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\dbg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysAssert.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysDbg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysDuplicateTable.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysEndian.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysEvents.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysEventsHandler.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysIdleHandler.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysIncrementMacro.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysInit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysMutex.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysQueue.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysRepeatMacro.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysSleep.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysStat.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysTaskManager.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysTimer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysTypes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\include\sysUtils.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\dbg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysAssert.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysDuplicateTable.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysEventsHandler.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysIdleHandler.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysInit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysMutex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysQueue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysSleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysStat.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysTaskManager.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysTimer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\SystemEnvironment\src\sysUtils.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>ZCL</name>
      <group>
        <name>include</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\clusters.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\eccAux.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\genericEcc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zcl.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclAlarmsCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclAttributes.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclBACnetProtocolTunnelCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclBasicCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclCommandAnalyzer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclDemandResponseCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclDiagnosticsCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclFanControlCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclGenericTunnelCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclGroupsCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclHumidityMeasurementCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclIasACECluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclIasZoneCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclIdentifyCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclIlluminanceMeasurementCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclInt.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclKeyEstablishmentCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclLevelControlCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclMem.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclMemoryManager.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclMessagingCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclOccupancySensingCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclOnOffCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclOnOffSwitchConfigurationCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclOtauClient.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclOTAUCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclOtauManager.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclParser.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclPowerConfigurationCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclPriceCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclScenesCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclSecurityManager.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclSimpleMeteringCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclSmartEnergyTunnelCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclTaskManager.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclTemperatureMeasurementCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclThermostatCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclThermostatUiConfCluster.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\include\zclTimeCluster.h</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zcl.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclAttributes.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclCommandAnalyzer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclKeyEstablishmentCluster.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclMemoryManager.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclOtauClient.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclOtauClientDiscovery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclOtauClientDownload.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclOtauClientPdt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclOtauClientQuery.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclOtauClientUpgrade.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclOtauManager.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclOtauServer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclParser.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclSecurityManager.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\BitCloud\Components\ZCL\src\zclTaskManager.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>configuration</name>
    <file>
      <name>$PROJ_DIR$\..\configuration.h</name>
    </file>
  </group>
  <group>
    <name>DimmableLight</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\include\dlBasicCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\include\dlClusters.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\include\dlGroupsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\include\dlIdentifyCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\include\dlLevelControlCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\include\dlOnOffCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\include\dlScenes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\include\dlScenesCluster.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dimmableLight.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlBasicCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlClusters.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlConsole.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlGroupsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlIdentifyCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlLevelControlCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlOnOffCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlPdt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlScenes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmableLight\src\dlScenesCluster.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>DimmerSwitch</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\include\dsAlarmsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\include\dsBasicCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\include\dsClusters.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\include\dsIdentifyCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\include\dsLevelControlCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\include\dsOnOffCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\include\dsPowerConfigurationCluster.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dimmerSwitch.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dsAlarmsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dsBasicCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dsClusters.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dsConsole.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dsIdentifyCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dsLevelControlCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dsOnOffCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\dimmerSwitch\src\dsPowerConfigurationCluster.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>ias_ace</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\include\iasACEBasicCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\include\iasACECluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\include\iasACEDiagnosticsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\include\iasACEIdentifyCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\include\iasACEZoneCluster.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\src\iasACE.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\src\iasACEBasicCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\src\iasACECluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\src\iasACEConsole.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\src\iasACEDiagnosticsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\src\iasACEIdentifyCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\src\iasACEPdt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\ias_ace\src\iasACEZoneCluster.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>MultiSensor</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msBasicCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msClusters.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msDiagnosticsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msGroupsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msHumidityMeasurementCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msIdentifyCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msIlluminanceMeasurementCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msOccupancySensingCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\include\msTemperatureMeasurementCluster.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msBasicCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msClusters.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msConsole.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msDiagnosticsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msGroupsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msHumidityMeasurementCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msIdentifyCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msIlluminanceMeasurementCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msOccupancySensingCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msPdt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\msTemperatureMeasurementCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\multiSensor\src\multiSensor.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>thermostat</name>
    <group>
      <name>include</name>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thAlarmsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thBasicCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thClusters.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thDiagnosticsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thFanControlCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thGroupsCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thHumidityMeasurementCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thIdentifyCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thOccupancySensingCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thScenes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thScenesCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thTemperatureMeasurementCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thThermostatCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thThermostatUiConfCluster.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\include\thTimeCluster.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thAlarmsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thBasicCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thClusters.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thConsole.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thDiagnosticsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thermostat.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thFanControlCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thGroupsCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thHumidityMeasurementCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thIdentifyCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thOccupancySensingCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thPdt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thScenes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thScenesCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thTemperatureMeasurementCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thThermostatCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thThermostatUiConfCluster.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\thermostat\src\thTimeCluster.c</name>
      </file>
    </group>
  </group>
</project>


