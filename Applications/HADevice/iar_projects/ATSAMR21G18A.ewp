# IAR project ATSAMR21G18A.ewp, settings and files
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_8Mhz (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_SAMR21; BOARD_QTOUCH_XPRO; AT86RF233; ATSAMR21G18A; HAL_8MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.CCDiagSuppress: Pa050,Pe188
  ICCARM.PreInclude: MakerulesBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.h
  ICCARM.CCIncludePath2: ..; ../dimmableLight/include; ../dimmerSwitch/include; ../multiSensor/include; ../thermostat/include; ../ias_ace/include; ../combinedInterface/include; ../common/include; ../common/clusters/include; ../../../BitCloud/Components/BSP/SAMR21/include; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/BSP/QTouch_XPRO/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/std/include; ../../../BitCloud/Components/PersistDataServer/wl/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/VCP/include; ../../../BitCloud/Components/HAL/cortexm0+/atsamr21/common/include; ../../../BitCloud/Components/ZCL/include/private; ../../../BitCloud/Components/ZCL/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/MAC_HWD/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ATSAMR21G18A
  OBJCOPY.OOCOutputFile: HADevice.srec
  ILINK.IlinkOutputFile: HADevice.out
  ILINK.IlinkIcfFile: ../linkerScr/atSAMR21G18A_FLASH.icf
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_8Mhz_Iar.a; ../../../BitCloud/Components/BSP/QTouch_XPRO/lib/SAMR21_iar_lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_4Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; HAL_4MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.CCIncludePath2: ..; ../dimmableLight/include; ../dimmerSwitch/include; ../multiSensor/include; ../thermostat/include; ../ias_ace/include; ../combinedInterface/include; ../common/include; ../common/clusters/include; ../../../BitCloud/Components/BSP/SAMR21/include; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/lib; ../../../BitCloud/Components/HAL/include; ../../../BitCloud/Components/BSP; ../../../BitCloud/Components/BSP/include; ../../../BitCloud/Components/NWK/include; ../../../BitCloud/Components/NWK/include/private; ../../../BitCloud/Components/ZDO/include; ../../../BitCloud/Components/ZDO/include/private; ../../../BitCloud/Components/APS/include; ../../../BitCloud/Components/APS/include/private; ../../../BitCloud/Components/SystemEnvironment/include; ../../../BitCloud/Components/ConfigServer/include; ../../../BitCloud/Components/ConfigServer/include/private; ../../../BitCloud/Components/PersistDataServer/include; ../../../BitCloud/Components/PersistDataServer/std/include; ../../../BitCloud/Components/PersistDataServer/wl/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Types/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Util/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Timer/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Task/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_ErrH/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Log/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Memory/include; ../../../BitCloud/Components/ZLLPlatform/Infrastructure/N_Init/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include; ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src; ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src; ../../../BitCloud/Components/Security/TrustCentre/include; ../../../BitCloud/Components/Security/ServiceProvider/include; ../../../BitCloud/Components/HAL/drivers/include; ../../../BitCloud/Components/HAL/drivers/VCP/include; ../../../BitCloud/Components/HAL/cortexm0+/atsamr21/common/include; ../../../BitCloud/Components/ZCL/include/private; ../../../BitCloud/Components/ZCL/include; ../../../BitCloud/Components/MAC_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_ENV/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWI/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/PHY/include; ../../../BitCloud/Components/MAC_PHY/MAC_HWD_PHY/RF231_RF212/MAC_HWD/include
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_4Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_16Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; HAL_16MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_16Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_24Mhz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; HAL_24MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_24Mhz_Iar.a
configuration All_StdlinkSec_SamR21_Atsamr21g18a_Rf233_48MHz (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_SAMR21; AT86RF233; ATSAMR21G18A; HAL_48MHz; STACK_TYPE_ALL; STDLINK_SECURITY_MODE
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkAdditionalLibs: ../../../BitCloud/lib/libBc_All_StdlinkSec_Atsamr21g18a_Rf233_Iar.a; ../../../BitCloud/lib/libHAL_SamR21_Atsamr21g18a_48MHz_Iar.a
  group CombinedInterface/include
    ../combinedInterface/include/: ciAlarmsCluster.h ciBasicCluster.h ciClusters.h ciDiagnosticsCluster.h ciFanControlCluster.h ciGroupsCluster.h ciHumidityMeasurementCluster.h ciIasACECluster.h ciIasZoneCluster.h ciIdentifyCluster.h ciIlluminanceMeasurementCluster.h ciLevelControlCluster.h ciOccupancySensingCluster.h ciOnOffCluster.h ciPowerConfigurationCluster.h ciScenesCluster.h ciTemperatureMeasurementCluster.h ciThermostatCluster.h ciThermostatUiConfCluster.h ciTimeCluster.h
  group CombinedInterface/src
    ../combinedInterface/src/: ciAlarmsCluster.c ciBasicCluster.c ciClusters.c ciConsole.c ciDiagnosticsCluster.c ciFanControlCluster.c ciGroupsCluster.c ciHumidityMeasurementCluster.c ciIasACECluster.c ciIasZoneCluster.c ciIdentifyCluster.c ciIlluminanceMeasurementCluster.c ciLevelControlCluster.c ciOccupancySensingCluster.c ciOnOffCluster.c ciPowerConfigurationCluster.c ciScenesCluster.c ciTemperatureMeasurementCluster.c ciThermostatCluster.c ciThermostatUiConfCluster.c ciTimeCluster.c combinedInterface.c
  group common/clusters/include
    ../common/clusters/include/: basicCluster.h haClusters.h identifyCluster.h
  group common/clusters/src
    ../common/clusters/src/: haClusters.c
  group common/include
    ../common/include/: appConsts.h commandManager.h console.h ezModeManager.h otauService.h uartManager.h zclDevice.h
  group common/src
    ../common/src/: commandManager.c console.c ezModeManager.c keyboardPoll.c otauService.c uartManager.c zclDevice.c
  group Components/BSP/include
    ../../../BitCloud/Components/BSP/SAMR21/include/: bspDbg.h bspLeds.h bspTaskManager.h bspTempSensor.h bspVoltageSensor.h ledsExt.h
    ../../../BitCloud/Components/BSP/SAMR21/src/: bspI2c.h
  group Components/BSP/QTOUCH/include
    ../../../BitCloud/Components/BSP/QTouch_XPRO/include/: qtTaskManager.h qtTimer.h touch.h touch_api_ptc.h
  group Components/BSP/QTOUCH/src
    ../../../BitCloud/Components/BSP/QTouch_XPRO/src/: qtTaskManager.c qtTimer.c touch.c
  group Components/BSP/src
    ../../../BitCloud/Components/BSP/SAMR21/src/: bspI2c.c bspSpi.c bspTaskManager.c bspTempSensor.c bspUid.c bspUsart.c bspVoltageSensor.c buttons.c fakeBSP.c hs2xy.c joystick.c lcd.c leds.c maxL.c xyl2rgb.c
  group Components/ConfigServer/include
    ../../../BitCloud/Components/ConfigServer/include/: configServer.h csDefaults.h
  group Components/ConfigServer/include/private
    ../../../BitCloud/Components/ConfigServer/include/private/: csBuffers.h csConstTable.h csDbg.h csMemTable.h csSIB.h csVarTable.h
  group Components/ConfigServer/src
    ../../../BitCloud/Components/ConfigServer/src/: configServer.c csMem.c csPersistentMem.c
  group Components/PersistDataServer/include
    ../../../BitCloud/Components/PersistDataServer/include/: pdsDataServer.h pdsMemIds.h
  group Components/PersistDataServer/src
    ../../../BitCloud/Components/PersistDataServer/src/: fakePds.c
  group Components/PersistDataServer/std/include
    ../../../BitCloud/Components/PersistDataServer/std/include/: stdPdsCrcService.h stdPdsDbg.h stdPdsFiles.h stdPdsMem.h stdPdsMemAbstract.h stdPdsMemAccess.h stdPdsMemIds.h stdPdsTimer.h stdPdsWriteData.h
  group Components/PersistDataServer/std/src
    ../../../BitCloud/Components/PersistDataServer/std/src/: stdPdsCrcService.c stdPdsDataServer.c stdPdsEvents.c stdPdsInit.c stdPdsMem.c stdPdsMemAccess.c stdPdsTimer.c stdPdsWriteData.c
  group Components/PersistDataServer/wl/include
    ../../../BitCloud/Components/PersistDataServer/wl/include/: wlPdsBindings.h wlPdsMemIds.h wlPdsSecurity.h wlPdsTaskManager.h wlPdsTypes.h wlPdsTypesConverter.h
  group Components/PersistDataServer/wl/nv_components/include
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/include/: D_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/include/: D_XNv.h D_XNv_Bindings.h D_XNv_Init.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/include/: S_Nv.h
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/include/: S_XNv_Bindings.h
  group Components/PersistDataServer/wl/nv_components/src
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_Nv/src/: D_Nv.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/D_XNv/src/: D_XNv-SamR21.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_Nv/src/: S_Nv-External.c S_Nv.c S_Nv_Stub.c
    ../../../BitCloud/Components/ZLLPlatform/ZLL/S_XNv/src/: S_XNv.c
  group Components/PersistDataServer/wl/src
    ../../../BitCloud/Components/PersistDataServer/wl/src/: wlPdsDataServer.c wlPdsInit.c wlPdsSecurity.c wlPdsTaskManager.c wlPdsTypesConverter.c
  group Components/SystemEnvironment/include
    ../../../BitCloud/Components/SystemEnvironment/include/: dbg.h sysAssert.h sysDbg.h sysDuplicateTable.h sysEndian.h sysEvents.h sysEventsHandler.h sysIdleHandler.h sysIncrementMacro.h sysInit.h sysMutex.h sysQueue.h sysRepeatMacro.h sysSleep.h sysStat.h sysTaskManager.h sysTimer.h sysTypes.h sysUtils.h
  group Components/SystemEnvironment/src
    ../../../BitCloud/Components/SystemEnvironment/src/: dbg.c sysAssert.c sysDuplicateTable.c sysEventsHandler.c sysIdleHandler.c sysInit.c sysMutex.c sysQueue.c sysSleep.c sysStat.c sysTaskManager.c sysTimer.c sysUtils.c
  group Components/ZCL/include
    ../../../BitCloud/Components/ZCL/include/: clusters.h eccAux.h genericEcc.h zcl.h zclAlarmsCluster.h zclAttributes.h zclBACnetProtocolTunnelCluster.h zclBasicCluster.h zclCommandAnalyzer.h zclDemandResponseCluster.h zclDiagnosticsCluster.h zclFanControlCluster.h zclGenericTunnelCluster.h zclGroupsCluster.h zclHumidityMeasurementCluster.h zclIasACECluster.h zclIasZoneCluster.h zclIdentifyCluster.h zclIlluminanceMeasurementCluster.h zclInt.h zclKeyEstablishmentCluster.h zclLevelControlCluster.h zclMem.h zclMemoryManager.h zclMessagingCluster.h zclOccupancySensingCluster.h zclOnOffCluster.h zclOnOffSwitchConfigurationCluster.h zclOtauClient.h zclOTAUCluster.h zclOtauManager.h zclParser.h zclPowerConfigurationCluster.h zclPriceCluster.h zclScenesCluster.h zclSecurityManager.h zclSimpleMeteringCluster.h zclSmartEnergyTunnelCluster.h zclTaskManager.h zclTemperatureMeasurementCluster.h zclThermostatCluster.h zclThermostatUiConfCluster.h zclTimeCluster.h
  group Components/ZCL/src
    ../../../BitCloud/Components/ZCL/src/: zcl.c zclAttributes.c zclCommandAnalyzer.c zclKeyEstablishmentCluster.c zclMemoryManager.c zclOtauClient.c zclOtauClientDiscovery.c zclOtauClientDownload.c zclOtauClientPdt.c zclOtauClientQuery.c zclOtauClientUpgrade.c zclOtauManager.c zclOtauServer.c zclParser.c zclSecurityManager.c zclTaskManager.c
  group configuration
    ../: configuration.h
  group DimmableLight/include
    ../dimmableLight/include/: dlBasicCluster.h dlClusters.h dlGroupsCluster.h dlIdentifyCluster.h dlLevelControlCluster.h dlOnOffCluster.h dlScenes.h dlScenesCluster.h
  group DimmableLight/src
    ../dimmableLight/src/: dimmableLight.c dlBasicCluster.c dlClusters.c dlConsole.c dlGroupsCluster.c dlIdentifyCluster.c dlLevelControlCluster.c dlOnOffCluster.c dlPdt.c dlScenes.c dlScenesCluster.c
  group DimmerSwitch/include
    ../dimmerSwitch/include/: dsAlarmsCluster.h dsBasicCluster.h dsClusters.h dsIdentifyCluster.h dsLevelControlCluster.h dsOnOffCluster.h dsPowerConfigurationCluster.h
  group DimmerSwitch/src
    ../dimmerSwitch/src/: dimmerSwitch.c dsAlarmsCluster.c dsBasicCluster.c dsClusters.c dsConsole.c dsIdentifyCluster.c dsLevelControlCluster.c dsOnOffCluster.c dsPowerConfigurationCluster.c
  group ias_ace/include
    ../ias_ace/include/: iasACEBasicCluster.h iasACECluster.h iasACEDiagnosticsCluster.h iasACEIdentifyCluster.h iasACEZoneCluster.h
  group ias_ace/src
    ../ias_ace/src/: iasACE.c iasACEBasicCluster.c iasACECluster.c iasACEConsole.c iasACEDiagnosticsCluster.c iasACEIdentifyCluster.c iasACEPdt.c iasACEZoneCluster.c
  group MultiSensor/include
    ../multiSensor/include/: msBasicCluster.h msClusters.h msDiagnosticsCluster.h msGroupsCluster.h msHumidityMeasurementCluster.h msIdentifyCluster.h msIlluminanceMeasurementCluster.h msOccupancySensingCluster.h msTemperatureMeasurementCluster.h
  group MultiSensor/src
    ../multiSensor/src/: msBasicCluster.c msClusters.c msConsole.c msDiagnosticsCluster.c msGroupsCluster.c msHumidityMeasurementCluster.c msIdentifyCluster.c msIlluminanceMeasurementCluster.c msOccupancySensingCluster.c msPdt.c msTemperatureMeasurementCluster.c multiSensor.c
  group thermostat/include
    ../thermostat/include/: thAlarmsCluster.h thBasicCluster.h thClusters.h thDiagnosticsCluster.h thFanControlCluster.h thGroupsCluster.h thHumidityMeasurementCluster.h thIdentifyCluster.h thOccupancySensingCluster.h thScenes.h thScenesCluster.h thTemperatureMeasurementCluster.h thThermostatCluster.h thThermostatUiConfCluster.h thTimeCluster.h
  group thermostat/src
    ../thermostat/src/: thAlarmsCluster.c thBasicCluster.c thClusters.c thConsole.c thDiagnosticsCluster.c thermostat.c thFanControlCluster.c thGroupsCluster.c thHumidityMeasurementCluster.c thIdentifyCluster.c thOccupancySensingCluster.c thPdt.c thScenes.c thScenesCluster.c thTemperatureMeasurementCluster.c thThermostatCluster.c thThermostatUiConfCluster.c thTimeCluster.c
